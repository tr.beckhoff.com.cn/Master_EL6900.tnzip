PROGRAM MAIN
VAR
	bErrAck		AT%Q*	:	BOOL;
	bRun		AT%Q*	:	BOOL;
	
	bComErr		AT%I*	:	BOOL;
	bOtherErr	AT%I*	:	BOOL;
END_VAR

END_PROGRAM
